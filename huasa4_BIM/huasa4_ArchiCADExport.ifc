Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-07-30T10:57:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.100.12 - Exporter 21.1.100.12 - Alternate UI 21.1.100.12
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 30 10:57:54 2025 * Host: Chatpong_D * Database: C:\Users\chatp\AppData\Local\Temp\0e6a5ffc-5407-4773-aec1-c5e6ebbb3456\8ecd7b3e-d53d-4d48-8353-2d562cd1d859\ifc * Database version: 5507 * Database creation date: Wed Jul 30 10:57:53 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 30 10:57:53 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 30 10:57:53 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: huasa4_REVIT:HAND SHOWER CONCEPT 4/FLUX DSS_v4.0, huasa4_REVIT:HAND SHOWER CONCEPT 4/FLUX DSS_v4.0:302259
In: Level 1
Type - Material: White, Steel, Chrome Plated
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: HAND SHOWER CONCEPT 4/FLUX DSS_v4.0
Pset_DistributionFlowElementCommon - Reference: HAND SHOWER CONCEPT 4/FLUX DSS_v4.0; sets with these values: 2
